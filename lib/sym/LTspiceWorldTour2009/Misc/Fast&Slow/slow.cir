* C:\LTspice\Slow.asc
V1 W 0 pulse(0 1 0 1u 1u 1m 2m)
V2 X 0 sine(0 1 1K)
V3 N264 0 0
V4 N272 0 0
V5 N280 0 0
V6 N288 0 0
V7 N296 0 0
V8 N304 0 0
V9 N312 0 0
V10 N320 0 0
V11 N328 0 0
V12 N336 0 0
V13 N344 0 0
V14 N352 0 0
V15 N360 0 0
V16 N368 0 0
V17 N376 0 0
V18 N384 0 0
V19 N392 0 0
V20 N400 0 0
V21 N408 0 0
V22 N416 0 0
V23 N424 0 0
V24 N432 0 0
V25 N440 0 0
V26 N448 0 0
V27 N456 0 0
V28 N464 0 0
V29 N472 0 0
V30 N480 0 0
V31 N488 0 0
V32 N496 0 0
V33 N504 0 0
V34 N512 0 0
V35 N263 0 0
V36 N271 0 0
V37 N279 0 0
V38 N287 0 0
V39 N295 0 0
V40 N303 0 0
V41 N311 0 0
V42 N319 0 0
V43 N327 0 0
V44 N335 0 0
V45 N343 0 0
V46 N351 0 0
V47 N359 0 0
V48 N367 0 0
V49 N375 0 0
V50 N383 0 0
V51 N391 0 0
V52 N399 0 0
V53 N407 0 0
V54 N415 0 0
V55 N423 0 0
V56 N431 0 0
V57 N439 0 0
V58 N447 0 0
V59 N455 0 0
V60 N463 0 0
V61 N471 0 0
V62 N479 0 0
V63 N487 0 0
V64 N495 0 0
V65 N503 0 0
V66 N511 0 0
V67 N262 0 0
V68 N270 0 0
V69 N278 0 0
V70 N286 0 0
V71 N294 0 0
V72 N302 0 0
V73 N310 0 0
V74 N318 0 0
V75 N326 0 0
V76 N334 0 0
V77 N342 0 0
V78 N350 0 0
V79 N358 0 0
V80 N366 0 0
V81 N374 0 0
V82 N382 0 0
V83 N390 0 0
V84 N398 0 0
V85 N406 0 0
V86 N414 0 0
V87 N422 0 0
V88 N430 0 0
V89 N438 0 0
V90 N446 0 0
V91 N454 0 0
V92 N462 0 0
V93 N470 0 0
V94 N478 0 0
V95 N486 0 0
V96 N494 0 0
V97 N502 0 0
V98 N510 0 0
V99 N261 0 0
V100 N269 0 0
V101 N277 0 0
V102 N285 0 0
V103 N293 0 0
V104 N301 0 0
V105 N309 0 0
V106 N317 0 0
V107 N325 0 0
V108 N333 0 0
V109 N341 0 0
V110 N349 0 0
V111 N357 0 0
V112 N365 0 0
V113 N373 0 0
V114 N381 0 0
V115 N389 0 0
V116 N397 0 0
V117 N405 0 0
V118 N413 0 0
V119 N421 0 0
V120 N429 0 0
V121 N437 0 0
V122 N445 0 0
V123 N453 0 0
V124 N461 0 0
V125 N469 0 0
V126 N477 0 0
V127 N485 0 0
V128 N493 0 0
V129 N501 0 0
V130 N509 0 0
V131 N260 0 0
V132 N268 0 0
V133 N276 0 0
V134 N284 0 0
V135 N292 0 0
V136 N300 0 0
V137 N308 0 0
V138 N316 0 0
V139 N324 0 0
V140 N332 0 0
V141 N340 0 0
V142 N348 0 0
V143 N356 0 0
V144 N364 0 0
V145 N372 0 0
V146 N380 0 0
V147 N388 0 0
V148 N396 0 0
V149 N404 0 0
V150 N412 0 0
V151 N420 0 0
V152 N428 0 0
V153 N436 0 0
V154 N444 0 0
V155 N452 0 0
V156 N460 0 0
V157 N468 0 0
V158 N476 0 0
V159 N484 0 0
V160 N492 0 0
V161 N500 0 0
V162 N508 0 0
V163 N259 0 0
V164 N267 0 0
V165 N275 0 0
V166 N283 0 0
V167 N291 0 0
V168 N299 0 0
V169 N307 0 0
V170 N315 0 0
V171 N323 0 0
V172 N331 0 0
V173 N339 0 0
V174 N347 0 0
V175 N355 0 0
V176 N363 0 0
V177 N371 0 0
V178 N379 0 0
V179 N387 0 0
V180 N395 0 0
V181 N403 0 0
V182 N411 0 0
V183 N419 0 0
V184 N427 0 0
V185 N435 0 0
V186 N443 0 0
V187 N451 0 0
V188 N459 0 0
V189 N467 0 0
V190 N475 0 0
V191 N483 0 0
V192 N491 0 0
V193 N499 0 0
V194 N507 0 0
V195 N258 0 0
V196 N266 0 0
V197 N274 0 0
V198 N282 0 0
V199 N290 0 0
V200 N298 0 0
V201 N306 0 0
V202 N314 0 0
V203 N322 0 0
V204 N330 0 0
V205 N338 0 0
V206 N346 0 0
V207 N354 0 0
V208 N362 0 0
V209 N370 0 0
V210 N378 0 0
V211 N386 0 0
V212 N394 0 0
V213 N402 0 0
V214 N410 0 0
V215 N418 0 0
V216 N426 0 0
V217 N434 0 0
V218 N442 0 0
V219 N450 0 0
V220 N458 0 0
V221 N466 0 0
V222 N474 0 0
V223 N482 0 0
V224 N490 0 0
V225 N498 0 0
V226 N506 0 0
V227 N257 0 0
V228 N265 0 0
V229 N273 0 0
V230 N281 0 0
V231 N289 0 0
V232 N297 0 0
V233 N305 0 0
V234 N313 0 0
V235 N321 0 0
V236 N329 0 0
V237 N337 0 0
V238 N345 0 0
V239 N353 0 0
V240 N361 0 0
V241 N369 0 0
V242 N377 0 0
V243 N385 0 0
V244 N393 0 0
V245 N401 0 0
V246 N409 0 0
V247 N417 0 0
V248 N425 0 0
V249 N433 0 0
V250 N441 0 0
V251 N449 0 0
V252 N457 0 0
V253 N465 0 0
V254 N473 0 0
V255 N481 0 0
V256 N489 0 0
V257 N497 0 0
V258 N505 0 0
V259 N008 0 0
V260 N016 0 0
V261 N024 0 0
V262 N032 0 0
V263 N040 0 0
V264 N048 0 0
V265 N056 0 0
V266 N064 0 0
V267 N072 0 0
V268 N080 0 0
V269 N088 0 0
V270 N096 0 0
V271 N104 0 0
V272 N112 0 0
V273 N120 0 0
V274 N128 0 0
V275 N136 0 0
V276 N144 0 0
V277 N152 0 0
V278 N160 0 0
V279 N168 0 0
V280 N176 0 0
V281 N184 0 0
V282 N192 0 0
V283 N200 0 0
V284 N208 0 0
V285 N216 0 0
V286 N224 0 0
V287 N232 0 0
V288 N240 0 0
V289 N248 0 0
V290 N256 0 0
V291 N007 0 0
V292 N015 0 0
V293 N023 0 0
V294 N031 0 0
V295 N039 0 0
V296 N047 0 0
V297 N055 0 0
V298 N063 0 0
V299 N071 0 0
V300 N079 0 0
V301 N087 0 0
V302 N095 0 0
V303 N103 0 0
V304 N111 0 0
V305 N119 0 0
V306 N127 0 0
V307 N135 0 0
V308 N143 0 0
V309 N151 0 0
V310 N159 0 0
V311 N167 0 0
V312 N175 0 0
V313 N183 0 0
V314 N191 0 0
V315 N199 0 0
V316 N207 0 0
V317 N215 0 0
V318 N223 0 0
V319 N231 0 0
V320 N239 0 0
V321 N247 0 0
V322 N255 0 0
V323 N006 0 0
V324 N014 0 0
V325 N022 0 0
V326 N030 0 0
V327 N038 0 0
V328 N046 0 0
V329 N054 0 0
V330 N062 0 0
V331 N070 0 0
V332 N078 0 0
V333 N086 0 0
V334 N094 0 0
V335 N102 0 0
V336 N110 0 0
V337 N118 0 0
V338 N126 0 0
V339 N134 0 0
V340 N142 0 0
V341 N150 0 0
V342 N158 0 0
V343 N166 0 0
V344 N174 0 0
V345 N182 0 0
V346 N190 0 0
V347 N198 0 0
V348 N206 0 0
V349 N214 0 0
V350 N222 0 0
V351 N230 0 0
V352 N238 0 0
V353 N246 0 0
V354 N254 0 0
V355 N005 0 0
V356 N013 0 0
V357 N021 0 0
V358 N029 0 0
V359 N037 0 0
V360 N045 0 0
V361 N053 0 0
V362 N061 0 0
V363 N069 0 0
V364 N077 0 0
V365 N085 0 0
V366 N093 0 0
V367 N101 0 0
V368 N109 0 0
V369 N117 0 0
V370 N125 0 0
V371 N133 0 0
V372 N141 0 0
V373 N149 0 0
V374 N157 0 0
V375 N165 0 0
V376 N173 0 0
V377 N181 0 0
V378 N189 0 0
V379 N197 0 0
V380 N205 0 0
V381 N213 0 0
V382 N221 0 0
V383 N229 0 0
V384 N237 0 0
V385 N245 0 0
V386 N253 0 0
V387 N004 0 0
V388 N012 0 0
V389 N020 0 0
V390 N028 0 0
V391 N036 0 0
V392 N044 0 0
V393 N052 0 0
V394 N060 0 0
V395 N068 0 0
V396 N076 0 0
V397 N084 0 0
V398 N092 0 0
V399 N100 0 0
V400 N108 0 0
V401 N116 0 0
V402 N124 0 0
V403 N132 0 0
V404 N140 0 0
V405 N148 0 0
V406 N156 0 0
V407 N164 0 0
V408 N172 0 0
V409 N180 0 0
V410 N188 0 0
V411 N196 0 0
V412 N204 0 0
V413 N212 0 0
V414 N220 0 0
V415 N228 0 0
V416 N236 0 0
V417 N244 0 0
V418 N252 0 0
V419 N003 0 0
V420 N011 0 0
V421 N019 0 0
V422 N027 0 0
V423 N035 0 0
V424 N043 0 0
V425 N051 0 0
V426 N059 0 0
V427 N067 0 0
V428 N075 0 0
V429 N083 0 0
V430 N091 0 0
V431 N099 0 0
V432 N107 0 0
V433 N115 0 0
V434 N123 0 0
V435 N131 0 0
V436 N139 0 0
V437 N147 0 0
V438 N155 0 0
V439 N163 0 0
V440 N171 0 0
V441 N179 0 0
V442 N187 0 0
V443 N195 0 0
V444 N203 0 0
V445 N211 0 0
V446 N219 0 0
V447 N227 0 0
V448 N235 0 0
V449 N243 0 0
V450 N251 0 0
V451 N002 0 0
V452 N010 0 0
V453 N018 0 0
V454 N026 0 0
V455 N034 0 0
V456 N042 0 0
V457 N050 0 0
V458 N058 0 0
V459 N066 0 0
V460 N074 0 0
V461 N082 0 0
V462 N090 0 0
V463 N098 0 0
V464 N106 0 0
V465 N114 0 0
V466 N122 0 0
V467 N130 0 0
V468 N138 0 0
V469 N146 0 0
V470 N154 0 0
V471 N162 0 0
V472 N170 0 0
V473 N178 0 0
V474 N186 0 0
V475 N194 0 0
V476 N202 0 0
V477 N210 0 0
V478 N218 0 0
V479 N226 0 0
V480 N234 0 0
V481 N242 0 0
V482 N250 0 0
V483 N001 0 0
V484 N009 0 0
V485 N017 0 0
V486 N025 0 0
V487 N033 0 0
V488 N041 0 0
V489 N049 0 0
V490 N057 0 0
V491 N065 0 0
V492 N073 0 0
V493 N081 0 0
V494 N089 0 0
V495 N097 0 0
V496 N105 0 0
V497 N113 0 0
V498 N121 0 0
V499 N129 0 0
V500 N137 0 0
V501 N145 0 0
V502 N153 0 0
V503 N161 0 0
V504 N169 0 0
V505 N177 0 0
V506 N185 0 0
V507 N193 0 0
V508 N201 0 0
V509 N209 0 0
V510 N217 0 0
V511 N225 0 0
V512 N233 0 0
V513 N241 0 0
V514 N249 0 0
R1 W 0 1K
R2 X 0 1K
V515 Y 0 pulse(0 1 0 1u 1u 100m 200m)
V516 Z 0 sine(0 1 10)
R3 Y 0 1K
R4 Z 0 1K
.options topologycheck=0
.tran 20
.end
